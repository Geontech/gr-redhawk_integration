<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fm_demod</value></param>
<param><key>author</key><value>Thomas Goodwin of Geon Technologies</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>http://www.instructables.com/id/RTL-SDR-FM-radio-receiver-with-GNU-Radio-Companion using gnuradio-redhawk integration</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>FM Demodulation example</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_interp</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>volume</value></param>
<param><key>value</key><value>50000</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>audio_interp</value></param>
<param><key>quad_rate</key><value>audio_rate * audio_interp</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>int(samp_rate)</value></param>
<param><key>interp</key><value>int(audio_rate * audio_interp)</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>redhawk_integration_rh_sink_bulkio</key>
<param><key>id</key><value>redhawk_integration_rh_sink_bulkio_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>sri_streamID</key><value>"gnuradio_flowgraph"</value></param>
<param><key>sri_subsize</key><value>0</value></param>
<param><key>sri_xdelta</key><value>1.0/samp_rate</value></param>
<param><key>sri_xunits</key><value>1</value></param>
<param><key>sri_ydelta</key><value>1.0</value></param>
<param><key>sri_yunits</key><value>0</value></param>
</block>
<block>
<key>redhawk_integration_rh_source_bulkio</key>
<param><key>id</key><value>redhawk_integration_rh_source_bulkio_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>redhawk_integration_rh_sink_bulkio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>redhawk_integration_rh_source_bulkio_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
